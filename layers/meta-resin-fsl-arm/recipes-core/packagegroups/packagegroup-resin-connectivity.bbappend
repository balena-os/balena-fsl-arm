# Hummingboard platforms have BCM4330 optional WiFi modules
CONNECTIVITY_FIRMWARES_append_cubox-i = " bcm4330-nvram-config bcm4329-nvram-config"
