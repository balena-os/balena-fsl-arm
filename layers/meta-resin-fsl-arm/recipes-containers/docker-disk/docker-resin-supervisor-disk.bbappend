# Nitrogen6x
SUPERVISOR_REPOSITORY_nitrogen6x = "resin/armv7hf-supervisor"

# cubox-i
SUPERVISOR_REPOSITORY_cubox-i = "resin/armv7hf-supervisor"
