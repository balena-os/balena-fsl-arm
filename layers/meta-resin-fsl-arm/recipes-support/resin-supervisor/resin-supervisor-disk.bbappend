# Nitrogen6x
TARGET_REPOSITORY_nitrogen6x = "resin/armv7hf-supervisor"

# cubox-i
TARGET_REPOSITORY_cubox-i = "resin/armv7hf-supervisor"

# imx6qsabresd
TARGET_REPOSITORY_imx6qsabresd = "resin/armv7hf-supervisor"
