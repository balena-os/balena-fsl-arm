FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
COMPATIBLE_MACHINE = "(wandboard|cubox-i|solidrun-imx6)"
