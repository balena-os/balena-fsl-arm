# common for both Artik 5 and Artik 10

SUPERVISOR_REPOSITORY = "resin/armv7hf-supervisor"
LED_FILE = "/dev/null"
