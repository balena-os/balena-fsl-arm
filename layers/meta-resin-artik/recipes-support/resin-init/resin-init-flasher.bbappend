# On Samsung Artik 5 and Artik 10, we flash Resin IO on the emmc
INTERNAL_DEVICE_KERNEL = "mmcblk0"
