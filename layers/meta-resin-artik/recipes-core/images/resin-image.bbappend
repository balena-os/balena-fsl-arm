include resin-image.inc

# custom uboot binary env data for eMMC boot
UBOOT_ENV_BIN = "params_emmc.bin"
