
LED_FILE:imx8mm-lpddr4-evk = "/sys/class/leds/status/brightness"
