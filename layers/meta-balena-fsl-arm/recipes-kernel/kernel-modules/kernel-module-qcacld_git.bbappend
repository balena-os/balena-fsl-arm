# Base N8MM switches to a different qca driver and
# firmware to support monitor mode. It now is recommended
# that we use it for the other boards too, for improved
# stability.
SRCBRANCH_nitrogen8mm = "boundary-CNSS.LEA.NRT_2.0"

SRCREV_nitrogen8mm = "e1a3e5f50d16a21a807b3d3fab77bb7dc6a57da2"

LIC_FILES_CHKSUM_nitrogen8mm = "file://${S}/CORE/HDD/src/wlan_hdd_main.c;beginline=1;endline=20;md5=ec8d62116b13db773825ebf7cf91be1d"
