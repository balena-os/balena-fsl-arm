# Use latest and known to work revision. Otherwise if
# booting fails at some point we won't know what caused it

# This revision is what we've tested to work in Dunfell
SRCREV = "6745ccdcf15384891639b7ced3aa6ce938682365"
