PACKAGE_INSTALL_remove_ccimx6ul = " \
    initramfs-module-e2fs \
    initramfs-module-fsck \
    initramfs-module-resindataexpander \
"

PACKAGE_INSTALL_append_ccimx6ul = "\
    mkfs-default-ubifs-parts \
    initramfs-module-ubifs-prepare-parts \
"
