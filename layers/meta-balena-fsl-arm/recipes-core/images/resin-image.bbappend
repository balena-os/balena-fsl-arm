include resin-image.inc

IMAGE_INSTALL_append_nitrogen8mm = " \
        bluetooth-scripts \
"
