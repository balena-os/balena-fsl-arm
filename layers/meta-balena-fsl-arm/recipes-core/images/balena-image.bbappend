include balena-image.inc

IMAGE_INSTALL:append:nitrogen8mm = " \
        bluetooth-scripts \
"
