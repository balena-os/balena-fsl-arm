RDEPENDS_${PN}_remove_ccimx6ul = " \
    dosfstools \
    resin-filesystem-expand \
    resin-extra-udev-rules \
    kernel-image-initramfs \
"
