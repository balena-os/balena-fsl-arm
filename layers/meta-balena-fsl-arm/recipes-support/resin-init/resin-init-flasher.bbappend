# Flash to internal eMMC - kernel always enumerates emmc as mmcblk2
INTERNAL_DEVICE_KERNEL_solidrun-imx6 = "mmcblk2"
INTERNAL_DEVICE_KERNEL_nitrogen8mm = "mmcblk0"
