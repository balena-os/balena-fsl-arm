FILESEXTRAPATHS:append:nitrogen8mm := "${THISDIR}/${PN}-nitrogen8mm"
FILESEXTRAPATHS:append:imx8mm-lpddr4-evk := "${THISDIR}/${PN}-imx8mm"
