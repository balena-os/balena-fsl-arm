FILESEXTRAPATHS_prepend_nitrogen8mm-dwe := "${THISDIR}/resin-init-board:"
