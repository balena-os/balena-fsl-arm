PACKAGECONFIG_remove = " egl glesv2"
